# Repository Mar-A-git/KiCad-manufacturing-guide

File README.md:

# KiCadで学ぶものづくりの流れ
【1日で学ぶKiCadによる基板設計入門】

KiCadを使った回路設計〜基板設計〜発注までの流れを学べる教材です。
詳しい解説はnoteマガジンで公開しています。

👉 [noteマガジン「KiCadの使い方」](https://note.com/mar_69/m/m424c03004c76)

## フォルダ構成

| フォルダ | 内容 |
|---|---|
| `materials/` | 教材PDF |
| `kicad-project/` | KiCadの回路図・基板データ |
| `production/` | 発注用データ(ガーバー、部品表) |

## バージョン
- Version: v1.0
- Last Updated: 2026.08.17

## 更新履歴
- v1.0 (2026.08.17): 初版公開

## ライセンス
このリポジトリの資料は [CC BY-NC-ND 4.0](https://creativecommons.org/licenses/by-nc-nd/4.0/deed.ja) の下で公開しています。

- ✅ 自由に印刷・配布可能(非営利目的に限る)
- ❌ 改変不可
- ❌ 商用利用不可(有料研修・販売など)
- 📌 利用の際は表紙の作者名・バージョン情報を削除しないでください

## Author
[@MarA_Elec](https://note.com/mar_69)

## KiCad design kicad-project/LED_REV1/LED_REV1.kicad_pcb

Parts:
C1: 1u; C2012
J1: BM03B-GHS-TBT
LED1: LTST-C230TBKT; CHIP_LED_3216
Q1: DTC114EKAT146; DTC114EKA
R1: 1k; R2012
R2: 10k; R2012
SW1: DTS-63-N-V-BLU; DTS-63-N-V-BLU(TS-0606-F-N-BLU)

Connections:
+3.3V: J1.1, R1.1, SW1.1, SW1.2
GND: C1.2, J1.3, Q1.1 (E)
unnamed: LED1.2 (A), R1.2
unnamed: LED1.1 (K), Q1.3 (C)
unnamed: C1.1, Q1.2 (B), R2.2
unnamed: R2.1, SW1.3, SW1.4

Notes on the sheet:
電源入力

Board: 2 copper layers, 60.0 x 40.0 mm, 7 parts (0 on the bottom side), 6 nets.
